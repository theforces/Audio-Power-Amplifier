** Profile: "SCHEMATIC1-Amplificator audio de putere"  [ D:\Pt facultate\P1_2018_432A_Moise_Andrei_Amplificator_audio_putere_N16_OrCAD\Schematics\amplificator audio de putere-pspicefiles\schematic1\amplificator audio de putere.sim ]

** Creating circuit file "Amplificator audio de putere.cir"
** WARNING: THIS AUTOMATICALLY GENERATED FILE MAY BE OVERWRITTEN BY SUBSEQUENT SIMULATIONS

*Libraries:
* Profile Libraries :
* Local Libraries :
.LIB "e:/pt facultate/anul 3/sem 1/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bc856b.lib"
.LIB "e:/pt facultate/anul 3/sem 1/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c8v2.lib"
.LIB "e:/pt facultate/anul 3/sem 1/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bc846b.lib"
.LIB "e:/pt facultate/anul 3/sem 1/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/mjd31cg.lib"
.LIB "e:/pt facultate/anul 3/sem 1/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bc817-25.lib"
.LIB "e:/pt facultate/anul 3/sem 1/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c2v7.lib"
.LIB "e:/pt facultate/anul 3/sem 1/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/1n4148.lib"
.LIB "e:/pt facultate/anul 3/sem 1/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bc807-25.lib"
.LIB "e:/pt facultate/anul 3/sem 1/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c5v1.lib"
.LIB "e:/pt facultate/anul 3/sem 1/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c5v6.lib"
.LIB "e:/pt facultate/anul 3/sem 1/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c6v8.lib"
.LIB "e:/pt facultate/anul 3/sem 1/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/bzx84c10.lib"
.LIB "e:/pt facultate/anul 3/sem 1/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/irfr120npbf.lib"
.LIB "e:/pt facultate/anul 3/sem 1/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/mjd32cg.lib"
.LIB "e:/pt facultate/anul 3/sem 1/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/mmbfj177lt1g.lib"
.LIB "e:/pt facultate/anul 3/sem 1/proiect 1/lib_modelepspice_anexa_1/modele_a1_lib/mmbfj309lt1g.lib"
* From [PSPICE NETLIST] section of C:\Users\Andrei\AppData\Roaming\SPB_16.6\cdssetup\OrCAD_PSpice/16.6.0/PSpice.ini file:
.lib "nomd.lib"

*Analysis directives:
.TRAN  0 2ms 0 50ns
.OPTIONS ADVCONV
.PROBE64 V(alias(*)) I(alias(*)) W(alias(*)) D(alias(*)) NOISE(alias(*))
.INC "..\SCHEMATIC1.net"

.END
